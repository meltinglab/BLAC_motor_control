<?xml version="1.0" encoding="UTF-8"?>
<!--
Auto generated XML Component Description for model pe_pmsm_drive_project
Model version                : 1.142
Simulink Coder version       : Simulink Coder 9.0 (R2018b) 24-May-2018
XML source code generated on : Sat Mar 23 00:31:02 2019
Model Checksum               : 3163894198 890542233 2035210945 787218297
-->
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd"/>
